# Keil uVision project yuexinmiao.uvprojx, settings and files
target yuexinmiao (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: yuexinmiao +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\vendor\Nuvoton\NUC131_BSP\Library\CMSIS\Include;..\..\vendor\Nuvoton\NUC131_BSP\Library\Device\Nuvoton\NUC131\Include;..\..\vendor\Nuvoton\NUC131_BSP\Library\StdDriver\inc;..\App;..\Drivers;..\Resources\generated
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC131.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../vendor/Nuvoton/NUC131_BSP/Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../../vendor/Nuvoton/NUC131_BSP/Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group Application
    ../App/: main.c fault_handlers.c animation_player.c animation_player.h
  group LCD Driver
    ../Drivers/: lcd_driver.c lcd_driver.h lcd_config.h gd25q64.c gd25q64.h
    ../Resources/generated/: animation_resource.h
  group NUC131 StdDriver
    ../../vendor/Nuvoton/NUC131_BSP/Library/StdDriver/src/: clk.c gpio.c sys.c spi.c timer.c
software components: CMSIS:CORE 5.2.0
